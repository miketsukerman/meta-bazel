TOOLCHAIN_TARGET_TASK += " \
    bazel \
    "
